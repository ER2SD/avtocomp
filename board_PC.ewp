# IAR project board_PC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x400
  General.GenHeapSize: 0x400
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: board_PC.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: board_PC.out
  group (top)
    ./: alarm.c alarm.h circle.c circle.h clock.c clock.h counter.c counter.h flash.c flash.h fm.c fm.h gidro_trans.c gidro_trans.h lcd.c lcd.h main.c menu.c menu.h set_pin.c set_pin.h speed.c speed.h valcoder.c valcoder.h
    $EW_DIR$/stm8/inc/: iostm8l152c6.h
